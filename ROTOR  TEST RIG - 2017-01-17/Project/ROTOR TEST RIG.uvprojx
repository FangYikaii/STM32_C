# Keil uVision project ROTOR TEST RIG.uvprojx, settings and files
target ROTOR TEST RIG (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XG +hex
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\Startup;..\Libraries\STM32F10x_StdPeriph_Driver_V3.5\inc;..\User\Include;..\Libraries\STM32_UDisk\FATFS_V0.08A\src;..\Libraries\STM32_UDisk\STM32_USB_HOST_Driver\inc;..\Libraries\STM32_UDisk\STM32_USB_HOST_Library\Class\HID\inc;..\Libraries\STM32_UDisk\STM32_USB_HOST_Library\Class\MSC\inc;..\Libraries\STM32_UDisk\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_UDisk\USB_User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ../User/Source/: main.c USB_UDisk.c MAX7219.c PCF8574.c CANx.c IOControl.c USARTx.c RTC.c ADC.c FrequencyCapture.c TimerX.c hw_config.c stm32f10x_it.c
  group Include
    ../User/Include/: main.h USB_UDisk.h MAX7219.h PCF8574.h CANx.h IOControl.h USARTx.h RTC.h ADC.h FrequencyCapture.h TimerX.h hw_config.h stm32f10x_it.h
  group Doc
    ../Doc/: CAN1_VS_CAN2.txt MAX7219.txt PCF8574.txt RTC.txt USARTx.txt USB_UDisk.txt FrequencyCapture.txt STM数据类型.txt Output Programm.txt
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group STM32F10x_StdPeriph_Driver_V3.5
    ../Libraries/STM32F10x_StdPeriph_Driver_V3.5/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dma.c
  group USB_Core
    ../Libraries/STM32_UDisk/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_MSC
    ../Libraries/STM32_UDisk/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_Driver
    ../Libraries/STM32_UDisk/STM32_USB_HOST_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group FATFS V0.08A
    ../Libraries/STM32_UDisk/FATFS_V0.08A/src/: diskio.c ff.c
  group USB_User
    ../Libraries/STM32_UDisk/USB_User/src/: usb_bsp.c usbh_usr.c
